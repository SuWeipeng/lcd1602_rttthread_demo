<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\stm32f4discovery-rtt.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>