# IAR project stm32f4discovery.ewp, settings and files
configuration stm32f4discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\Drivers; ..\Drivers\CMSIS; ..\Drivers\CMSIS\Device; ..\Drivers\CMSIS\Device\ST; ..\Drivers\CMSIS\Device\ST\STM32F4xx; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\LCD1602_4W\Inc; ..\Drivers\STM32F4xx_HAL_Driver; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Inc; ..\Middlewares; ..\Middlewares\ST; ..\Middlewares\ST\STM32_USB_Device_Library; ..\Middlewares\ST\STM32_USB_Device_Library\Class; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\Third_Party; ..\Middlewares\Third_Party\FatFs; ..\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: ..\IDE\IAR\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ../Drivers/LCD1602_4W/Src/: LCD.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Middlewares
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Src
    ../Src/: fatfs.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c user_diskio.c
  group StartUp
    ../IDE/IAR/: startup_stm32f407xx.s
  group default
    ../Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../Middlewares/Third_Party/FatFs/src/: diskio.h ff.h ff_gen_drv.h integer.h
    ../Inc/: fatfs.h ffconf.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h user_diskio.h
    ../Drivers/LCD1602_4W/Inc/: LCD.h LCD_Config.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_usb.h
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
