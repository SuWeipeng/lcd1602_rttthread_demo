# IAR project stm32f4discovery-rtt.ewp, settings and files
configuration stm32f4discovery-rtt (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\Drivers; ..\Drivers\CMSIS; ..\Drivers\CMSIS\Device; ..\Drivers\CMSIS\Device\ST; ..\Drivers\CMSIS\Device\ST\STM32F4xx; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F4xx_HAL_Driver; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Inc; ..\Libraries; ..\Libraries\rt-thread; ..\Libraries\rt-thread\board-407vg; ..\Libraries\rt-thread\components; ..\Libraries\rt-thread\components\drivers; ..\Libraries\rt-thread\components\drivers\include; ..\Libraries\rt-thread\HAL_Drivers; ..\Libraries\rt-thread\include; ..\Libraries\rt-thread\include\libc; ..\Middlewares; ..\Middlewares\ST; ..\Middlewares\ST\STM32_USB_Device_Library; ..\Middlewares\ST\STM32_USB_Device_Library\Class; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\Third_Party; ..\Middlewares\Third_Party\FatFs; ..\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: ..\IDE\IAR\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Middlewares
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group RTThread
    ../Libraries/rt-thread/board-407vg/: board.c
    ../Libraries/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../Libraries/rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
    ../Libraries/rt-thread/HAL_Drivers/: drv_common.c
  group Src
    ../Src-rtt/: entry.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c user_diskio.c
  group StartUp
    ../IDE/IAR/: startup_stm32f407xx.s
  group default
    ../Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../Libraries/rt-thread/board-407vg/: board.h
    ../Middlewares/Third_Party/FatFs/src/: diskio.h ff.h ff_gen_drv.h integer.h
    ../Libraries/rt-thread/HAL_Drivers/: drv_common.h
    ../Libraries/rt-thread/: entry.h rtconfig.h
    ../Inc/: fatfs.h ffconf.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h user_diskio.h
    ../Libraries/rt-thread/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_signal.h libc_stat.h
    ../Libraries/rt-thread/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
    ../Libraries/rt-thread/components/drivers/include/: rtdevice.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_usb.h
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
